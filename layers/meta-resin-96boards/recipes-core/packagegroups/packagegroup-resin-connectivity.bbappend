CONNECTIVITY_FIRMWARES = " \
    linux-firmware-wl12xx \
    linux-firmware-wl18xx \
"
